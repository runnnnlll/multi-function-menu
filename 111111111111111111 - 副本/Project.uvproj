# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h key.c key.h LCD1602.c LCD1602.h cai1.c cai1.h Timer0.c Timer0.h PWM.c PWM.h light.c light.h send.c send.h rec.c rec.h timers.c Timer1.c clock.c Timer2.c
